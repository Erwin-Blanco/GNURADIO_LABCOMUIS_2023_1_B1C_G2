options:
  parameters:
    generate_options: qt_gui
    id: parte_4_b_1
    output_language: python
    title: uis-e3t
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: amplitud portadora
    start: '0'
    step: '1e-6'
    stop: '1'
    value: '1'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: 'amplitud del mensaje '
    start: '0'
    step: '1e-6'
    stop: '1'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: 'ganancia del transmisor '
    start: '0'
    step: '1'
    stop: '30'
    value: '1'
  states: {}
- name: Kp
  id: variable_qtgui_range
  parameters:
    label: coeficiente Kp
    start: '0'
    step: '1e-6'
    stop: '10'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia de la portadora
    start: 50e6
    step: 1e6
    stop: 2e9
    value: 50e6
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: 'frecuencia del mensaje '
    start: 1e3
    step: '100'
    stop: 200e3
    value: 1e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: ENVOLVENTECOMPLEJAPM_0
  id: ENVOLVENTECOMPLEJAPM
  parameters:
    Ac: '100e-3'
    Kp: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: 200e3
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: 200e3
    fc: '0'
    fftsize: '8192'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    srate: 200e3
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: '0'
    gain0: '0'
    samp_rate: 200e3
    sync: sync
    type: fc32
  states: {}

connections:
- [ENVOLVENTECOMPLEJAPM_0, '0', qtgui_freq_sink_x_0, '0']
- [ENVOLVENTECOMPLEJAPM_0, '0', qtgui_time_sink_x_0, '0']
- [ENVOLVENTECOMPLEJAPM_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', ENVOLVENTECOMPLEJAPM_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
