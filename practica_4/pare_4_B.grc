options:
  parameters:
    author: 'ESTUDIANTES UIS '
    category: '[ModulosErwin]'
    copyright: UIS
    description: ROLLADO PARA ESTUDIAR LA ENVOLVENTE COMPLEJA DE UNA
    generate_options: hb
    id: ENVOLVENTE_COMPLEJA_PM
    output_language: python
    title: ENVOLVENTE COMPLEJA PM L1A
  states: {}

blocks:
- name: Ac
  id: parameter
  parameters:
    label: 'amplitud de  portadora '
    type: eng_float
    value: '100e-3'
  states: {}
- name: Kp
  id: parameter
  parameters:
    label: 'coeficiente de modulacion '
    type: eng_float
    value: '1'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '100E-3'
    type: complex
  states: {}
- name: blocks_transcendental_0
  id: blocks_transcendental
  parameters:
    name: COS
    type: float
  states: {}
- name: blocks_transcendental_0_0
  id: blocks_transcendental
  parameters:
    name: SIN
    type: float
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}

connections:
- [blocks_float_to_complex_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_transcendental_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_transcendental_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', pad_sink_0, '0']
- [blocks_transcendental_0, '0', blocks_float_to_complex_0, '0']
- [blocks_transcendental_0_0, '0', blocks_float_to_complex_0, '1']
- [pad_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
