options:
  parameters:
    author: Erwin
    copyright: UIS
    generate_options: qt_gui
    id: generador_amplitud_GNU_radio
    output_language: python
    title: modulador_AM_GNU_radio
  states: {}

blocks:
- name: AM
  id: variable_qtgui_range
  parameters:
    label: amplitud mensaje
    start: '-4'
    step: '0.01'
    stop: '4'
    value: '1'
  states: {}
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: amplitud de la portadora
    start: '0'
    step: '0.01'
    stop: '0.5'
    value: '0.25'
  states: {}
- name: FM
  id: variable_qtgui_range
  parameters:
    label: frecuencia del mensaje
    start: '0'
    step: '100'
    stop: '20000'
    value: '1000'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: ganancia del transmisor
    start: '0'
    step: '1'
    stop: '31'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia portadora
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: ka
  id: variable_qtgui_range
  parameters:
    label: coeficiente de sencibilidad AM
    start: '-4'
    step: '0.01'
    stop: '4'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12.5e6/64
  states: {}
- name: CALCULODEPOTENCIAJ1C_0
  id: CALCULODEPOTENCIAJ1C
  parameters:
    I_vect: '1024'
  states: {}
- name: Modulador_AM_Erwin_0
  id: Modulador_AM_Erwin
  parameters:
    Ac: Ac
    ka: ka
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: AM
    freq: FM
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"envolvente compleja" '
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"envolvente compleja"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [Modulador_AM_Erwin_0, '0', blocks_complex_to_real_0, '0']
- [Modulador_AM_Erwin_0, '0', qtgui_freq_sink_x_0, '0']
- [Modulador_AM_Erwin_0, '0', qtgui_time_sink_x_0, '0']
- [Modulador_AM_Erwin_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', Modulador_AM_Erwin_0, '0']
- [blocks_complex_to_real_0, '0', CALCULODEPOTENCIAJ1C_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
